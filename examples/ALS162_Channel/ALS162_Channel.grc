options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: ALS162_Channel
    output_language: python
    title: ALS162 Channel
  states: {}

blocks:
- name: NoiseGain
  id: variable_qtgui_range
  parameters:
    label: Noise Gain
    start: '0'
    step: '0.05'
    stop: '2.5'
    value: '0.25'
  states: {}
- name: c
  id: variable
  parameters:
    comment: speed of light
    value: 3e8
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 0.1e6
    stop: 6e6
    value: 3.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(192000)
  states: {}
- name: v
  id: variable
  parameters:
    comment: speed
    value: 3/3.6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: NoiseGain
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1'
    type: complex
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '12'
    comment: |-
      configuration inspired by:
      https://www.bastibl.net/rayleigh-autocorrelation/
    fDTs: freq * v / c / samp_rate
    seed: '0'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '55554'
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    maxoutbuf: '384000'
    minoutbuf: '192000'
    port: '55553'
    server: 'False'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      TBD: The signal received by
      the SDR also includes
      some occasional glitches
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', network_tcp_sink_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [channels_fading_model_0, '0', blocks_add_xx_0, '0']
- [network_tcp_source_0, '0', channels_fading_model_0, '0']

metadata:
  file_format: 1
