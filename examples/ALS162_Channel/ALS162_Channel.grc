options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: ALS162_Channel
    output_language: python
    title: ALS162 Channel
  states: {}

blocks:
- name: NoiseGain
  id: variable_qtgui_range
  parameters:
    label: Noise Gain
    start: '0'
    step: '0.05'
    stop: '2.5'
    value: '0.25'
  states: {}
- name: c
  id: variable
  parameters:
    comment: speed of light
    value: 3e8
  states: {}
- name: fading_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      low frequency => slow erfades
      high frequency => faster fades
    start: 1e6
    step: 0.1e6
    stop: 6e6
    value: 3.5e6
  states: {}
- name: fading_toggle_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: |-
      enable/disable
      fading effect
    initPressed: 'False'
    label: Fading (on/off)
    pressBackgroundColor: green
    pressFontColor: black
    pressed: '1'
    relBackgroundColor: gray
    relFontColor: black
    released: '0'
    type: int
    value: '0'
  states: {}
- name: impulse_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      high threshold
      => less interference
      threshold must be
      below range_uniform
    start: '0'
    step: '1'
    stop: int(32768e4)
    value: '327679500'
  states: {}
- name: interference_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      multiplicative gain for
      interference signals
    start: '0'
    step: '0.01'
    stop: '1000'
    value: '500'
  states: {}
- name: interference_toggle_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: |-
      enable/disable
      impulsive interference effect
    initPressed: 'False'
    label: Interference (on/off)
    pressBackgroundColor: green
    pressFontColor: black
    pressed: '1'
    relBackgroundColor: gray
    relFontColor: black
    released: '0'
    type: int
    value: '0'
  states: {}
- name: range_uniform
  id: variable_qtgui_range
  parameters:
    comment: |-
      range of values for
      uniform source
    start: '0'
    step: '1'
    stop: int(32768e4)
    value: int(32768e4)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(192000)
  states: {}
- name: v
  id: variable
  parameters:
    comment: speed
    value: 3/3.6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: NoiseGain
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      produce a rare
      impulse signal
    maximum: range_uniform
    minimum: '0'
    seed: '1'
    type: int
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '150'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      to scale the signal
      with a selectable gain
    const: interference_gain
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: impulse_thres
    init: '0'
    low: impulse_thres
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '12'
    comment: |-
      configuration inspired by:
      https://www.bastibl.net/rayleigh-autocorrelation/
    fDTs: fading_freq * v / c / samp_rate
    seed: '0'
  states: {}
- name: channels_fading_model_0_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '12'
    comment: |-
      similar to the intended
      signal this signal is subject
      to fading
    fDTs: 10.0/samp_rate
    seed: '0'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    comment: |-
      should provide a 
      waveform similar to
      a sine cardinale
    fft_size: '1024'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: '55'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '55554'
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    maxoutbuf: '384000'
    minoutbuf: '192000'
    port: '55553'
    server: 'False'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This block creates the
      impulsive interference
      (roughly  a sine cardinale
      waveform)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: synthetized interference
    stream_id: '1'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_random_uniform_source_x_0, '0', blocks_int_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_selector_0, '0']
- [blocks_add_xx_0, '0', network_tcp_sink_0, '0']
- [blocks_int_to_float_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_xx_1, '0', fft_vxx_0_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0_0, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_threshold_ff_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_0, '0', channels_fading_model_0_0, '0']
- [channels_fading_model_0, '0', blocks_selector_0_0, '1']
- [channels_fading_model_0_0, '0', virtual_sink_0, '0']
- [fading_toggle_button, state, blocks_selector_0_0, iindex]
- [fft_vxx_0, '0', blocks_multiply_xx_1, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [interference_toggle_button, state, blocks_selector_0, iindex]
- [network_tcp_source_0, '0', blocks_selector_0_0, '0']
- [network_tcp_source_0, '0', channels_fading_model_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '1']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
