options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: ALS162_Receiver
    output_language: python
    title: ALS162_Receiver
  states: {}

blocks:
- name: bits
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '12'
  states: {}
- name: diff_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: diff_gain
    start: '1'
    step: '1'
    stop: '800'
    value: '265'
  states: {}
- name: freq_ALS162
  id: variable
  parameters:
    value: '162000'
  states: {}
- name: fun_prob
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: shift_poll_freq
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Amplify receving
      signal power
    gui_hint: (0,0)
    label: Receiver Gain
    start: '1'
    step: '1'
    stop: '1000'
    value: '750'
  states: {}
- name: one_two
  id: variable_qtgui_range
  parameters:
    gui_hint: (11,0)
    label: One Two Threshold
    start: '0'
    step: '1'
    stop: '10000'
    value: '3000'
  states: {}
- name: phase_shift
  id: variable
  parameters:
    value: phase_shift_fct.shift_phase(fun_prob)
  states: {}
- name: pll_bw
  id: variable_qtgui_range
  parameters:
    start: '0.005'
    step: '0.0001'
    stop: '1'
    value: '0.025'
  states: {state: disabled}
- name: pll_limit
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: shift_poll_freq
  id: variable_qtgui_range
  parameters:
    label: shift_poll_freq
    start: '0'
    step: '100'
    stop: samp_rate
    value: '24000'
  states: {}
- name: shift_step
  id: variable_qtgui_range
  parameters:
    label: shift_step
    start: '0.00000'
    step: '0.00001'
    stop: '0.00350'
    value: '0.00100'
  states: {}
- name: threshold_spike
  id: variable_qtgui_range
  parameters:
    gui_hint: (13,0)
    label: Spike Threshold
    start: '0'
    step: '100'
    stop: '25000'
    value: '15000'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1000'
    gain: '750'
    samp_rate: samp_rate
    width: '250'
    win: window.WIN_BLACKMAN
  states: {}
- name: zero_one
  id: variable_qtgui_range
  parameters:
    gui_hint: (7,0)
    label: Zero One Threshold
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: zoom
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0)
    label: zoom
    start: '0'
    step: '10'
    stop: '25000'
    value: '4200'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: gain
    reference: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: zero_hi
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: zero_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: one_lower_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: one_upper_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0_0_1
  id: analog_const_source_x
  parameters:
    const: two_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: one_lower_hi
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: one_upper_hi
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1_0_0
  id: analog_const_source_x
  parameters:
    const: threshold_spike
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1_1
  id: analog_const_source_x
  parameters:
    const: two_hi
    type: float
  states: {state: disabled}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: |-
      alternative approach  for
      phase  drift compensation

      (the parallel path above  and
      the input to the phase shift  must
      be removed if this block is used)
    max_freq: 2*math.pi*pll_limit/samp_rate
    min_freq: '-2*math.pi*pll_limit/samp_rate'
    w: 2*math.pi*pll_bw/samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: byte
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_4
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended
    const: '0'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {state: disabled}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    comment: get 0 value
    type: byte
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    comment: get +2 value
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0
  id: blocks_and_xx
  parameters:
    comment: get -2 value
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_and_xx_0_1
  id: blocks_and_xx
  parameters:
    comment: get +1 value
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0
  id: blocks_and_xx
  parameters:
    comment: get -1 value
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      to obtain the
      phase of the
      complex signal
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: received signal power
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      compute average phase:
      * if it is too short, it
         overcompensates and
         disturbs the desired 
         short-time phases
      * if it is too long, it converges
         too slowly due to delay
    length: '15000'
    max_iter: '25000'
    scale: 1/15000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      smoothening by removing
      glitches from a noisy phase

      (Averaging seems sufficent.
      A median filter will probably
      provide better noise
      resilience, but seems more
      performance-critical)
    length: '20'
    max_iter: '150'
    scale: 1/20
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      to remove glitches
      from a noisy
      derivative of the phase
    length: '20'
    max_iter: '150'
    scale: 1/20
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: positive values
    const: '+1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: positive values
    const: diff_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: bits
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bits+300
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-bits-300'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bits+200
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-bits-200'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: negative values
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      just to be visible
      in the (non-normalized)
      plot
    const: '1000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/750
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_6_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_6_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_6_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_6_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: |-
      weighting parameter for
      corrective feedback
    const: shift_step
    type: float
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_1
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_2
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_2_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    comment: |-
      apply phase drift
      correction by shifting
      the phase to the
      opposite direction
      of the current long
      time average phase
      towards zero
    is_radians: 'True'
    shift: '0'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: extreme spike upwards
    high: threshold_spike
    init: '0'
    low: threshold_spike
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    comment: extreme spike downwards
    high: threshold_spike
    init: '0'
    low: threshold_spike
  states: {}
- name: blocks_threshold_ff_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      above this value
      is a +2, below a +1
    high: one_two
    init: '0'
    low: one_two
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      above this value
      is a -2, above a -1
    high: one_two
    init: '0'
    low: one_two
  states: {}
- name: blocks_threshold_ff_0_0_0_0_1
  id: blocks_threshold_ff
  parameters:
    comment: |-
      below this value
      is a 0, above a +1
    high: zero_one
    init: '0'
    low: zero_one
  states: {}
- name: blocks_threshold_ff_0_0_0_0_1_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      below this value
      is a 0, above a -1
    high: zero_one
    init: '0'
    low: zero_one
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1'
    type: complex
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    comment: |-
      get phase drift correction
      value from probe function
      (to deactivate if PLL Carrier
      tracking is activated)
    msgname: comp
    target: phase_shift
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n# counted number of one samples for +1\n_num_ones_p1 = 0\n# counted number of one samples for -1\n_num_ones_m1 = 0\n# counted number of one samples for  0\n_num_ones_z0 = 0\n# counted number of one samples for +2\n_num_ones_p2 = 0\n# counted number of one samples for -2\n_num_ones_m2 = 0\n\n\nclass blk(gr.sync_block):\n\n    def __init__(self, sample_rate=24000, tolerance=0.004):\n\n        gr.sync_block.__init__(\n            self,\n            name='ALS162\\nSymbol Detector',\n            in_sig=[np.float32, np.float32, np.float32,\n                    np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        self.sample_rate = sample_rate\n        self._tolerance = self.sample_rate*tolerance\n\n        # each subframe lasts approx. 25ms\n        self._subframe = int(0.025 * self.sample_rate)\n        self._subframe_lo = self._subframe - self._tolerance\n        self._subframe_lo2 = self._subframe - self._tolerance*3.0\n\n        print(\"subframe_lo: \", self._subframe_lo)\n        print(\"subframe_lo2: \", self._subframe_lo2)\n        print(\"tolerance_length: \", self._tolerance)\n\n        # NOTE: Frequently streaming lots of very short messages\n        # within extremely short time frames may lead to occasional\n        # message loss and hence to subsequent decoding errors.\n        # The message queue simply stores multiple successive symbols.\n        # Once the queue is full, concatenated message of the stored\n        # symbols is send.\n        self.queue_len = 20\n        self.queue = gr.msg_queue(self.queue_len)\n\n    def work(self, input_items, output_items):\n        inp_p1 = input_items[0]     # +1\n        inp_m1 = input_items[1]     # -1\n        inp_z0 = input_items[2]     # 0\n        inp_p2 = input_items[3]     # +2\n        inp_m2 = input_items[4]     # -2\n\n        output_items[0][:] = self.extract_bits(inp_p1, inp_m1,\n                                               inp_z0, inp_p2, inp_m2)\n\n        # transmit tagged stream\n        return len(output_items[0])\n\n    def clear_counters(self):\n        global _num_ones_p1\n        global _num_ones_m1\n        global _num_ones_z0\n        global _num_ones_p2\n        global _num_ones_m2\n\n        _num_ones_p1 = 0\n        _num_ones_m1 = 0\n        _num_ones_z0 = 0\n        _num_ones_p2 = 0\n        _num_ones_m2 = 0\n\n    def send_msg(self, val, num):\n        # handles both the message ouput queue\n        # and the message transmission\n        _msg = \"\"\n\n        if num > 0:\n            for i in range(0, num):\n                _msg += val\n\n            # convert python string to message\n            msg1_in = gr.message_from_string(_msg)\n\n            # insert message into queue\n            self.queue.insert_tail(msg1_in)\n\n        msg_list = [0]*self.queue_len\n\n        # send a combination of all messages contained in queue\n        if self.queue.full_p():\n            for idx in range(0, self.queue_len):\n                msg_list[idx] = self.queue.delete_head().\\\n                                     to_string().decode(\"utf-8\")\n\n            msg1_out = \"\".join(map(str, msg_list))\n            self.message_port_pub(pmt.intern(\"msg_out\"),\n                                  pmt.intern(msg1_out))\n\n    def extract_bits(self, inp_p1, inp_m1, inp_z0, inp_p2, inp_m2):\n        global _num_ones_p1\n        global _num_ones_m1\n        global _num_ones_z0\n        global _num_ones_p2\n        global _num_ones_m2\n\n        out = np.zeros(len(inp_p1))\n\n        # iterate through all five (parallel) input streams concurrently\n        for idx in range(len(inp_p1)):\n            # get symbol values at same idx for each input stream\n            ch_p1 = inp_p1[idx]\n            ch_m1 = inp_m1[idx]\n            ch_z0 = inp_z0[idx]\n            ch_p2 = inp_p2[idx]\n            ch_m2 = inp_m2[idx]\n\n            # increment current counters of ones per\n            # input stream, correspondingly\n            if ch_p1 == 1:\n                _num_ones_p1 += 1\n\n            if ch_m1 == 1:\n                _num_ones_m1 += 1\n\n            if ch_p2 == 1:\n                _num_ones_p2 += 1\n\n            if ch_m2 == 1:\n                _num_ones_m2 += 1\n\n            if ch_z0 == 1:\n                _num_ones_z0 += 1\n\n            # detect symbols (+/-2, +-1, 0)\n            # within tolerated chip-size when\n            # slope goes back to zero again\n            if (ch_p2 == 0 and\n                    _num_ones_p2 >= self._subframe_lo2):\n\n                _num = round(_num_ones_p2/self._subframe)\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"+2,{_num}\")\n                value = pmt.intern(f\"+2\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                out[idx] = 2\n\n                self.send_msg(val=\"+2,\", num=_num)\n                self.clear_counters()\n\n            if (ch_m2 == 0 and\n                    _num_ones_m2 >= self._subframe_lo2):\n\n                _num = round(_num_ones_m2/self._subframe)\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"-2,{_num}\")\n                value = pmt.intern(f\"-2\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                out[idx] = -2\n                self.send_msg(val=\"-2,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch_p1 == 0 and\n                    _num_ones_p1 >= self._subframe_lo):\n\n                _num = round(_num_ones_p1/self._subframe)\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"+1,{_num}\")\n                value = pmt.intern(f\"+1\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                out[idx] = 1\n                self.send_msg(val=\"+1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch_p1 == 1 and\n                    _num_ones_p1 >= self._subframe):\n\n                # will be 1 anyway...\n                # _num = round(_num_ones_z0/self._subframe)\n                _num = 1\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"+1,{_num}\")\n                value = pmt.intern(f\"+1\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = 1\n                self.send_msg(val=\"+1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch_m1 == 0 and\n                    _num_ones_m1 >= self._subframe_lo):\n\n                _num = round(_num_ones_m1/self._subframe)\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"-1,{_num}\")\n                value = pmt.intern(f\"-1\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = -1\n                self.send_msg(val=\"-1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch_m1 == 1 and\n                    _num_ones_m1 >= self._subframe):\n\n                # will be 1 anyway...\n                # _num = round(_num_ones_z0/self._subframe)\n                _num = 1\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"-1,{_num}\")\n                value = pmt.intern(f\"-1\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = -1\n                self.send_msg(val=\"-1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch_z0 == 0 and\n                    _num_ones_z0 >= self._subframe_lo2):\n\n                _num = round(_num_ones_z0/self._subframe)\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"0,{_num}\")\n                value = pmt.intern(f\"0\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                self.send_msg(val=\"0,\", num=_num)\n\n                self.clear_counters()\n\n            # In case there is a longer stream of consecutive zeros\n            # it is better to split the symbol stream into manageable\n            # chunks. Otherwise, successive the decoder might get too\n            # many zeros during the minute marker.\n            if (ch_z0 == 1 and\n                    _num_ones_z0 >= self._subframe):\n\n                # will be 1 anyway...\n                # _num = round(_num_ones_z0/self._subframe)\n                _num = 1\n\n                key = pmt.intern(\"\")\n                #value = pmt.intern(f\"0,{_num}\")\n                value = pmt.intern(f\"0\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                self.send_msg(val=\"0,\", num=_num)\n\n                self.clear_counters()\n\n        return out\n"
    comment: |-
      detects chip symbols
      with the values:
      +/-2, +/-1 and 0
      and provides one
      message per detected
      time-slice
    sample_rate: int(samp_rate/decimation)
    tolerance: '0.004'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n# counted number of one samples for +1\n_num_ones_p1 = 0\n# counted number of one samples for -1\n_num_ones_m1 = 0\n# counted number of one samples for  0\n_num_ones_z0 = 0\n# counted number of one samples for +2\n_num_ones_p2 = 0\n# counted number of one samples for -2\n_num_ones_m2 = 0\n\n# This alternative detector can operate on a single input stream\n# of all 5 symbols (+2,+1, 0,-1,-2) combined.\nclass blk(gr.sync_block):\n\n    def __init__(self, sample_rate=24000, tolerance=0.003):\n\n        gr.sync_block.__init__(\n            self,\n            name='ALS162\\nSymbol Detector 2',\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        self.sample_rate = sample_rate\n        self._tolerance = self.sample_rate*tolerance\n\n        # each subframe lasts approx. 25ms\n        self._subframe = int(0.025 * self.sample_rate)\n        self._subframe_lo = self._subframe - self._tolerance\n        self._subframe_lo2 = self._subframe - self._tolerance*3.0\n\n        print(\"subframe_lo: \", self._subframe_lo)\n        print(\"subframe_lo2: \", self._subframe_lo2)\n        print(\"tolerance_length: \", self._tolerance)\n\n        # NOTE: Frequently streaming lots of very short messages\n        # within extremely short time frames may lead to occasional\n        # message loss and hence to subsequent decoding errors.\n        # The message queue simply stores multiple successive symbols.\n        # Once the queue is full, concatenated message of the stored\n        # symbols is send.\n        self.queue_len = 20\n        self.queue = gr.msg_queue(self.queue_len)\n\n    def work(self, input_items, output_items):\n        inp = input_items[0]\n\n        output_items[0][:] = self.extract_bits(inp)\n\n        # transmit tagged stream\n        return len(output_items[0])\n\n    def clear_counters(self):\n        global _num_ones_p1\n        global _num_ones_m1\n        global _num_ones_z0\n        global _num_ones_p2\n        global _num_ones_m2\n\n        _num_ones_p1 = 0\n        _num_ones_m1 = 0\n        _num_ones_z0 = 0\n        _num_ones_p2 = 0\n        _num_ones_m2 = 0\n\n    def send_msg(self, val, num):\n        # handles both the message ouput queue\n        # and the message transmission\n        _msg = \"\"\n\n        if num > 0:\n            for i in range(0, num):\n                _msg += val\n\n            # convert python string to message\n            msg1_in = gr.message_from_string(_msg)\n\n            # insert message into queue\n            self.queue.insert_tail(msg1_in)\n\n        msg_list = [0]*self.queue_len\n\n        # send a combination of all messages contained in queue\n        if self.queue.full_p():\n            for idx in range(0, self.queue_len):\n                msg_list[idx] = self.queue.delete_head().\\\n                                     to_string().decode(\"utf-8\")\n\n            msg1_out = \"\".join(map(str, msg_list))\n            self.message_port_pub(pmt.intern(\"msg_out\"),\n                                  pmt.intern(msg1_out))\n\n    def extract_bits(self, inp):\n        global _num_ones_p1\n        global _num_ones_m1\n        global _num_ones_z0\n        global _num_ones_p2\n        global _num_ones_m2\n\n        out = np.zeros(len(inp))\n\n        # iterate through all five (parallel) input streams concurrently\n        for idx in range(len(inp)):\n            # get symbol value at index for input stream\n            ch = inp[idx]\n\n            # increment current counters of ones per\n            # input stream, correspondingly\n            if ch == 1:\n                _num_ones_p1 += 1\n\n            if ch == -1:\n                _num_ones_m1 += 1\n\n            if ch == 2:\n                _num_ones_p2 += 1\n\n            if ch == -2:\n                _num_ones_m2 += 1\n\n            if ch == 0:\n                _num_ones_z0 += 1\n\n            # detect symbols (+/-2, +-1, 0)\n            # within tolerated time-slice when\n            # slope goes back to zero again\n            if (ch != 2 and\n                    _num_ones_p2 >= self._subframe_lo2):\n\n                _num = round(_num_ones_p2/self._subframe)\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"+2,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                out[idx] = 2\n\n                self.send_msg(val=\"+2,\", num=_num)\n                self.clear_counters()\n\n            if (ch != -2 and\n                    _num_ones_m2 >= self._subframe_lo2):\n\n                _num = round(_num_ones_m2/self._subframe)\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"-2,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                out[idx] = -2\n                self.send_msg(val=\"-2,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch != 1 and\n                    _num_ones_p1 >= self._subframe_lo):\n\n                _num = round(_num_ones_p1/self._subframe)\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"+1,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                out[idx] = 1\n                self.send_msg(val=\"+1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch == 1 and\n                    _num_ones_p1 >= self._subframe):\n\n                # will be 1 anyway...\n                # _num = round(_num_ones_z0/self._subframe)\n                _num = 1\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"+1,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = 1\n                self.send_msg(val=\"+1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch != -1 and\n                    _num_ones_m1 >= self._subframe_lo):\n\n                _num = round(_num_ones_m1/self._subframe)\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"-1,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = -1\n                self.send_msg(val=\"-1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch == -1 and\n                    _num_ones_m1 >= self._subframe):\n\n                # will be 1 anyway...\n                # _num = round(_num_ones_z0/self._subframe)\n                _num = 1\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"-1,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = -1\n                self.send_msg(val=\"-1,\", num=_num)\n\n                self.clear_counters()\n\n            if (ch != 0 and\n                    _num_ones_z0 >= self._subframe_lo2):\n\n                _num = round(_num_ones_z0/self._subframe)\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"0,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                self.send_msg(val=\"0,\", num=_num)\n\n                self.clear_counters()\n\n            # In case there is a longer stream of consecutive zeros\n            # it is better to split the symbol stream into manageable\n            # chunks. Otherwise, successive the decoder might get too\n            # many zeros during the minute marker.\n            if (ch == 0 and\n                    _num_ones_z0 >= self._subframe):\n\n                # will be 1 anyway...\n                # _num = round(_num_ones_z0/self._subframe)\n                _num = 1\n\n                key = pmt.intern(\"c\")\n                value = pmt.intern(f\"0,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                self.send_msg(val=\"0,\", num=_num)\n\n                self.clear_counters()\n\n        return out\n"
    comment: |-
      detects chip symbols
      with the values:
      +/-2, +/-1 and 0
      and provides one
      message per detected
      time-slice
    sample_rate: int(samp_rate/decimation)
    tolerance: '0.003'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      # https://www.geeksforgeeks.org/python-rotate-dictionary-by-k/


      from gnuradio import gr
      import pmt
      import numpy as np


      # track the seconds
      _counter = 0

      # sliding window for selected messages
      _msg_window = np.empty(shape=(1, 1))


      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='ALS162 Code\nSequence Correlation',
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              # error threshold for position code distance
              self.position_thres = 3

              # error threshold for symbol code distance
              self.symbol_thres = 1

              # NOTE: symbol 2 counts both as minute marker and as a zero value
              self.symbol_code_dict = {
                  "0": (+1,-1,-1,+1, 0, 0, 0, 0),
                  "1": (+1,-1,-1,+1,+1,-1,-1,+1),
                  "2": ( 0, 0, 0, 0, 0, 0, 0, 0)
              }

              # table maps positions to codewords (reversing the dictionary above)
              self.symbol_code_swap_dict = \
                  {v: k for k, v in self.symbol_code_dict.items()}

              # table maps codewords to positions
              # NOTE: do not put position "00" to the front as this would
              # lead to dropping position "59" each minute
              self.position_code_dict = {
                  "01": ( 0,+1,-1, 0, 0, 0,+1,-1, 0, 0, 0, 0, 0, 0, 0,-1,
                          0,+2, 0,-2, 0,+2, 0,-2, 0,+1, 0, 0, 0, 0, 0, 0),
                  "02": (+1, 0,-2, 0,+2,-1,-1,+1,+1,-1,-1,+1, 0,+1, 0,-2,
                         +1, 0, 0,+1,-2, 0,+1, 0,+1,-1,-1,+1, 0, 0, 0, 0),
                  "03": (+1,-1, 0, 0,-1,+2, 0,-1,-1, 0,+2,-1,-1,+2, 0,-1,
                         -1, 0,+2,-1,-1,+2, 0,-1,-1, 0,+1, 0, 0, 0, 0, 0),
                  "04": (+1,-1,-1,+1,+1, 0,-1,-1,+1, 0,-1,+1, 0, 0, 0,+1,
                          0,-2,+1,+1,-1,-1, 0,+1,+1,-1,-1,+1, 0, 0, 0, 0),
                  "05": (+1,-1, 0,+1,-2, 0,+1, 0,+1, 0,-1,-1, 0,+2, 0,-1,
                         -1, 0,+1,+1,-1,-1,+2,-1,-1,+1, 0, 0, 0, 0, 0, 0),
                  "06": (+1,-1,-1,+1,+1, 0,-1,-1, 0,+1, 0,+1, 0,-2, 0,+2,
                          0,-2,+1,+1,-1,-1, 0,+2,-1,-1,+1, 0, 0, 0, 0, 0),
                  "07": ( 0, 0, 0, 0,+1, 0,-1, 0,-1, 0,+1,+1, 0,-1,-1,+1,
                          0, 0, 0,-1,+1,+1, 0,-1,-1, 0,+1, 0, 0, 0, 0, 0),
                  "08": ( 0, 0,+1, 0,-1, 0, 0, 0, 0,-1, 0,+1, 0, 0, 0, 0,
                          0, 0, 0, 0, 0,+1,-1,-1,+2,-1,-1,+1, 0, 0, 0, 0),
                  "09": (+1,-1, 0,+1,-2,+1, 0,-1,+1,+1,-1,-1,+1,+1, 0,-1,
                         -1, 0,+1,+1, 0,-1,-1, 0,+1, 0, 0, 0, 0, 0, 0, 0),
                  "10": ( 0,+1, 0,-1,-1, 0,+1,+1, 0,-1,-1, 0,+2,-1,-1,+1,
                         +1, 0,-1,-1,+1,+1,-2, 0,+1, 0, 0, 0, 0, 0, 0, 0),
                  "11": ( 0,+1, 0,-1,-1,+1,+1,-2,+1, 0,-1,+1, 0,+1,-1, 0,
                         +1,-1, 0,-1, 0,+2,-1, 0, 0,-1,+1, 0, 0, 0, 0, 0),
                  "12": ( 0,+1, 0,-1, 0, 0,-1, 0,+2,-1,-1,+1,+1, 0,-1, 0,
                         -1, 0,+1, 0, 0, 0, 0, 0,+1,-1,-1,+1, 0, 0, 0, 0),
                  "13": (+1,-1,-1,+2, 0,-1,-1, 0,+1,+1,-1, 0,+1,-2, 0,+1,
                         +1,-1,-1,+1, 0, 0,+1, 0,-1,-1, 0,+1, 0, 0, 0, 0),
                  "14": (+1, 0,-2,+1,+1,-2,+1, 0,-1,+2, 0,-2, 0,+1,+1,-1,
                          0, 0,-1,+1,+1,-1,-1,+2, 0,-2, 0,+1, 0, 0, 0, 0),
                  "15": ( 0,+1,-1,-1,+1,+1, 0,-1, 0,-1, 0,+2, 0,-1, 0,-1,
                          0,+2,-1, 0,+1,-2, 0,+2,-1,-1,+1, 0, 0, 0, 0, 0),
                  "16": ( 0, 0,+1, 0,-2,+1,+1,-1, 0, 0,-1,+1, 0,-1,+1, 0,
                          0, 0, 0,+1, 0,-2,+1,+1,-1,-1, 0,+1, 0, 0, 0, 0),
                  "17": (+1, 0,-2, 0,+2,-1, 0,+1,-1, 0, 0,-1,+1,+1,-1, 0,
                          0,-1,+1,+1,-2,+1,+1,-2, 0,+1, 0, 0, 0, 0, 0, 0),
                  "18": (+1,-1, 0,+1,-2, 0,+2,-1, 0,+1,-1, 0, 0,-1, 0,+2,
                          0,-1, 0,-1,+1, 0,-1,+1, 0, 0, 0, 0, 0, 0, 0, 0),
                  "19": (+1, 0,-1, 0,-1, 0,+1,+1,-1, 0,+1,-2, 0,+2,-1,-1,
                         +1, 0, 0,+1,-1,-1,+1, 0, 0, 0, 0, 0, 0, 0, 0, 0),
                  "20": (+1,-1,-1,+1, 0,+1, 0,-2, 0,+1, 0,+1,-1, 0,+1,-2,
                          0,+2,-1, 0,+1,-2, 0,+2,-1,-1,+1, 0, 0, 0, 0, 0),
                  "21": ( 0, 0,+1,-1,-1,+2,-1, 0,+1,-1, 0,-1, 0,+1,+1,-1,
                          0,+1,-2,+1,+1,-1, 0,-1, 0,+1, 0, 0, 0, 0, 0, 0),
                  "22": (+1,-1,-1,+2,-1, 0, 0,-1,+1, 0,+1, 0,-1,-1, 0,+2,
                          0,-2, 0,+2, 0,-1, 0,-1,+1, 0,-1,+1, 0, 0, 0, 0),
                  "23": ( 0, 0, 0, 0,+1, 0,-1, 0, 0, 0, 0, 0,-1,+1,+1,-2,
                         +1, 0, 0,+1,-1,-1, 0,+2, 0,-2, 0,+1, 0, 0, 0, 0),
                  "24": ( 0, 0, 0, 0,+1,-1, 0, 0, 0,+1,-2,+1, 0,-1,+2, 0,
                         -1,-1,+1,+1,-2,+1,+1,-1, 0,-1, 0,+1, 0, 0, 0, 0),
                  "25": (+1, 0,-2, 0,+1, 0, 0, 0,+1, 0,-2, 0,+2, 0,-1, 0,
                          0,-1,+1, 0, 0,+1,-2,+1,+1,-2, 0,+1, 0, 0, 0, 0),
                  "26": (+1,-1, 0,+1,-2, 0,+2,-1, 0, 0, 0,+1,-2, 0,+2,-1,
                         -1,+1, 0,+1,-1, 0,+1,-1,-1, 0,+1, 0, 0, 0, 0, 0),
                  "27": (+1, 0,-2, 0,+1,+1,-1,-1,+1, 0,+1, 0,-2, 0,+2, 0,
                         -1,-1,+1, 0,-1,+1,+1, 0,-2, 0,+1, 0, 0, 0, 0, 0),
                  "28": (+1, 0,-1,-1,+1,+1,-2,+1, 0, 0,+1,-2, 0,+1, 0,+1,
                         -1,-1,+2, 0,-1, 0,-1,+1,+1,-2, 0,+1, 0, 0, 0, 0),
                  "29": ( 0,+1,-1,-1,+2, 0,-2, 0,+2, 0,-1, 0, 0, 0, 0,-1,
                          0,+2,-1,-1,+1, 0,+1,-1,-1,+1, 0, 0, 0, 0, 0, 0),
                  "30": (+1, 0,-2, 0,+2,-1,-1,+1, 0,+1, 0,-2, 0,+2, 0,-2,
                         +1, 0, 0,+1,-2, 0,+1,+1, 0,-2, 0,+1, 0, 0, 0, 0),
                  "31": ( 0,+1,-1, 0,+1,-2, 0,+1,+1, 0,-2,+1,+1,-1, 0,-1,
                          0,+2, 0,-1,-1, 0,+2,-1,-1,+1, 0, 0, 0, 0, 0, 0),
                  "32": ( 0, 0,+1, 0,-2,+1,+1,-1,-1, 0,+1,+1, 0,-2, 0,+1,
                          0, 0, 0,+1, 0,-2,+1, 0, 0, 0,-1,+1, 0, 0, 0, 0),
                  "33": (+1, 0,-1, 0,-1,+1, 0,-1,+1, 0, 0,+1,-1, 0,+1,-1,
                          0, 0, 0,-1, 0,+1,+1, 0,-2, 0,+1, 0, 0, 0, 0, 0),
                  "34": ( 0, 0, 0, 0,+1, 0,-2, 0,+2,-1,-1,+2, 0,-1, 0, 0,
                          0,-1,+1,+1,-1, 0, 0, 0,-1, 0,+1, 0, 0, 0, 0, 0),
                  "35": ( 0, 0, 0,+1, 0,-1, 0, 0,-1, 0,+1, 0,+1, 0,-2,+1,
                          0, 0,+1,-1, 0,-1, 0,+1,+1,-1,-1,+1, 0, 0, 0, 0),
                  "36": (+1,-1, 0,+1,-1, 0, 0, 0,-1, 0,+2,-1, 0, 0, 0, 0,
                         -1,+1, 0, 0, 0,+1,-1, 0, 0,-1,+1, 0, 0, 0, 0, 0),
                  "37": (+1,-1,-1,+1, 0,+1,-1,-1,+1,+1,-1,-1,+1, 0,+1, 0,
                         -2,+1, 0, 0,+1,-1,-1, 0,+1, 0, 0, 0, 0, 0, 0, 0),
                  "38": ( 0,+1, 0,-2,+1,+1,-1, 0, 0, 0,-1, 0,+2,-1,-1,+1,
                         +1, 0,-2, 0,+1,+1,-1,-1,+1, 0, 0, 0, 0, 0, 0, 0),
                  "39": ( 0,+1, 0,-1,-1,+1,+1,-2, 0,+2,-1,-1,+1,+1,-1, 0,
                         +1,-1, 0,-1, 0,+2,-1,-1,+1, 0, 0, 0, 0, 0, 0, 0),
                  "40": ( 0,+1, 0,-1, 0, 0,-1, 0,+2,-1,-1,+1,+1,-1,-1,+1,
                         +1, 0,-1, 0, 0, 0, 0, 0,-1, 0,+1, 0, 0, 0, 0, 0),
                  "41": ( 0,+1, 0,-1,-1,+1,+1,-2,+1,+1,-1, 0,-1, 0,+2,-1,
                         -1,+1, 0,+1, 0,-2,+1, 0,-1,+1, 0, 0, 0, 0, 0, 0),
                  "42": (+1, 0,-1,-1,+1, 0,-1,+2, 0,-1,-1,+1,+1,-2, 0,+2,
                         -1,-1,+2, 0,-2, 0,+2, 0,-1,-1, 0,+1, 0, 0, 0, 0),
                  "43": (+1, 0,-1, 0,-1, 0,+2, 0,-2, 0,+2,-1, 0,+1,-1, 0,
                          0, 0, 0,-1,+1, 0,-1,+1,+1,-1,-1,+1, 0, 0, 0, 0),
                  "44": ( 0,+1,-1,-1,+2, 0,-2, 0,+2,-1, 0, 0, 0, 0, 0,+1,
                         -2,+1, 0,-1,+1, 0, 0, 0,+1,-1,-1,+1, 0, 0, 0, 0),
                  "45": ( 0,+1, 0,-1, 0, 0,-1,+1,+1,-2,+1, 0,-1,+2, 0,-2,
                          0,+1, 0, 0, 0, 0, 0,+1,-1,-1,+1, 0, 0, 0, 0, 0),
                  "46": (+1,-1,-1,+1,+1,-1,-1,+2, 0,-2, 0,+2,-1,-1,+1,+1,
                          0,-2,+1,+1,-2, 0,+2, 0,-2, 0,+1, 0, 0, 0, 0, 0),
                  "47": ( 0, 0,+1, 0,-2, 0,+1, 0,+1, 0,-2,+1, 0,-1,+2,-1,
                          0, 1,-1,-1,+1,+1,-2,+1,+1,-2, 0,+1, 0, 0, 0, 0),
                  "48": (+1, 0,-1,-1,+1, 0, 0,+1,-2,+1, 0,-1,+2, 0,-2,+1,
                          0,-1,+2, 0,-2,+1, 0, 0, 1,-2, 0,+1, 0, 0, 0, 0),
                  "49": (+1,-1,-1,+2,-1,-1,+2, 0,-2, 0,+2, 0,-1, 0, 0, 0,
                         -1,+1,+1,-2,+1, 0,-1,+1,+1,-1,-1,+1, 0, 0, 0, 0),
                  "50": ( 0, 0,+1, 0,-2, 0,+1, 0,+1,-1, 0, 0, 0, 0, 0,+1,
                         -1, 0, 0,-1,+1,+1,-1, 0,-1, 0,+1, 0, 0, 0, 0, 0),
                  "51": (+1,-1,-1,+1, 0, 0, 0,+1,-1, 0,+1,-1,-1, 0,+2, 0,
                         -2,+1, 0, 0, 0,-1,+1, 0, 0, 0, 0, 0, 0, 0, 0, 0),
                  "52": (+1, 0,-1,-1,+1,+1,-1, 0, 0, 0, 0,-1,+1, 0,-1,+2,
                         -1,-1,+2, 0,-1,-1,+1,+1,-1,-1, 0,+1, 0, 0, 0, 0),
                  "53": ( 0,+1, 0,-1,-1, 0,+2, 0,-2, 0,+1,+1,-1,-1,+1,+1,
                          0,-1, 0,-1,+1, 0,-1,+1,+1,-1,-1,+1, 0, 0, 0, 0),
                  "54": (+1, 0,-1,-1, 0,+1,+1, 0,-2,+1, 0, 0, 0, 0, 0, 0,
                          0,-1,+2,-1, 0, 0, 0, 0,-1,+1, 0, 0, 0, 0, 0, 0),
                  "55": ( 0, 0,+1,-1, 0,+1,-2, 0,+2,-1,-1,+2,-1, 0, 0, 0,
                          0,-1,+2, 0,-1, 0,-1,+1, 0,-1,+1, 0, 0, 0, 0, 0),
                  "56": ( 0, 0, 0, 0, 0, 0, 0,+1,-1,-1,+2, 0,-2, 0,+1, 0,
                          0,+1,-1, 0, 0,-1,+2,-1, 0, 0,-1,+1, 0, 0, 0, 0),
                  "57": ( 0, 0,+1, 0,-2,+1, 0, 0,+1,-1,-1,+1, 0, 0,+1,-2,
                         +1,+1,-1,-1, 0,+1, 0,+1, 0,-2, 0,+1, 0, 0, 0, 0),
                  "58": (+1, 0,-1, 0,-1,+1, 0,-1,+2,-1,-1,+2,-1,-1,+2,-1,
                          0,+1,-1,-1, 0,+1, 0, 0,+1,-1,-1,+1, 0, 0, 0, 0),
                  "59": (+1, 0,-2, 0,+2, 0,-2, 0,+2, 0,-2, 0,+2, 0,-2, 0,
                         +2, 0,-2, 0,+1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0),
                  "00": ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
                          0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)
              }

              self.position_code_swap_dict = \
                  {v: k for k, v in self.position_code_dict.items()}

          def prepare_window(self, msg):
              global _msg_window

              # message contains the whole sequence of a received second
              msg = pmt.to_python(msg)

              # first put each string into an array (separated by comma)
              received_msg = msg.split(",")

              # truncate last element ("") from list
              received_msg = received_msg[:-1]

              # convert to numpy-array
              np_recv_seq = np.array(received_msg)

              # turn each array element into an integer value
              np_recv_seq = np.asarray(np_recv_seq, dtype=np.int32)

              _msg_window = np.append(_msg_window, np_recv_seq)

          def rotate_dict(self, dictionary, K):
              # circular rotation of the dictionary entries
              keys = list(dictionary.keys())
              vals = list(dictionary.values())

              keys = keys[K:] + keys[:K]
              vals = vals[K:] + vals[:K]

              return dict(zip(keys, vals))

          def compare_position_code(self, dictionary, msg_window, first_offs=8):
              global _counter

              min_dist = 15
              min_dist_idx = 0
              # NOTE: this position key causes the decoder to reset
              pos_key = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
                          0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)

              for idx, key in enumerate(dictionary):
                  # turn tuple into numpy array
                  np_key = np.array(list(key))

                  # there must be at least 8 chips offset before
                  # that position codeword containing the time information
                  # (symbol 0 or 1)!
                  for offset in range(first_offs, first_offs + 40):
                      # decision metric: compare window with current codeword
                      # by the (Euclidean distance metric) 2-norm
                      dist = np.linalg.norm(msg_window[offset:offset + 32] - np_key)

                      # update current minimum
                      if min_dist > dist:
                          min_dist = dist

                      # check decision threshold for minimum
                      if dist <= self.position_thres:
                          min_dist = dist
                          min_dist_idx = offset
                          break

                  if min_dist <= self.position_thres:
                      pos_key = key
                      break

              # to save almost all iterations in the next run
              # NOTE: unclear if rotating the dict is actually
              # faster than simply iterating over all 60 keys
              # in the worst case (if this step is omitted)?
              shift_val = int(dictionary[pos_key], 10) - _counter
              dictionary = self.rotate_dict(dictionary, shift_val)

              _counter = int(dictionary[pos_key], 10)

              if min_dist > self.position_thres:
                  print("error, dropped position symbol:", msg_window)
                  pos_key = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
                              0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)

              return [min_dist, min_dist_idx, pos_key, dictionary]

          def compare_symbol_code(self, dictionary, symbol_window, first_offs=0):
              min_dist = 15
              symb_key = ( 1, -1, -1, 1, 0, 0, 0, 0)

              for key in dictionary:
                  # turn tuple into numpy array
                  np_key = np.array(list(key))

                  # decision metric: compare window with current time-symbol-
                  # codeword using the (Euclidean distance metric) 2-norm
                  for offset in range(first_offs,
                                      max(1, len(symbol_window) - len(np_key) + 1)):
                      dist = np.linalg.norm(
                          symbol_window[offset:offset + 8] - np_key)

                      # update current minimum
                      if min_dist > dist:
                          min_dist = dist

                      # check decision threshold for minimum
                      if min_dist <= self.symbol_thres:
                          symb_key = key
                          break

                  if min_dist <= self.symbol_thres:
                      symb_key = key
                      break

              if min_dist > self.symbol_thres:
                  print("error, dropped time symbol:", symbol_window)
                  symb_key = ( 1, -1, -1, 1, 0, 0, 0, 0)

              return symb_key

          def handle_msg(self, msg):
              global _msg_window

              self.prepare_window(msg)

              if len(_msg_window) >= 79:
                  cur_window = _msg_window.copy()

                  # find position-codeword in _msg_window
                  [min_dist, min_dist_idx, pos_key,
                      self.position_code_swap_dict] = \
                      self.compare_position_code(
                      dictionary=self.position_code_swap_dict,
                      msg_window=_msg_window.copy(),
                      first_offs=8)

                  symbol_window = _msg_window.copy()

                  # truncate codeword from front
                  if min_dist < self.position_thres:
                      _msg_window = _msg_window[min_dist_idx + len(pos_key):]

                      # mask time-symbol-codeword in front of position-codeword
                      symbol_window = symbol_window[min_dist_idx - 8:min_dist_idx]

                      # detect time-symbol-codeword in symbol_window
                      symb_key = self.compare_symbol_code(
                          dictionary=self.symbol_code_swap_dict,
                          symbol_window=symbol_window,
                          first_offs=0)

                      symb_code = self.symbol_code_swap_dict[symb_key]
                      pos_code = self.position_code_swap_dict[pos_key]

                      msg1_out = f"{symb_code}, {pos_code}"
                      self.message_port_pub(pmt.intern("msg_out"),
                                            pmt.intern(msg1_out))

                  # try to decode the time-symbol-codeword,
                  # even though decoding the position-codword has failed
                  else:
                      print("decoding error in current window:\n", cur_window)
                      # mask time-symbol-codeword in front of position-codeword
                      # symbol_window = symbol_window[min_dist_idx-8:min_dist_idx]
                      # symbol_window = cur_window.copy()[:42]

                      # detect time-symbol-codeword in symbol_window
                      symb_key = self.compare_symbol_code(
                          dictionary=self.symbol_code_swap_dict,
                          symbol_window=symbol_window,
                          first_offs=0)

                      symb_code = self.symbol_code_swap_dict[symb_key]
                      pos_code = self.position_code_swap_dict[pos_key]

                      msg1_out = f"{symb_code}, {pos_code}"
                      self.message_port_pub(pmt.intern("msg_out"),
                                            pmt.intern(msg1_out))

                      _msg_window = _msg_window[30:]
    comment: |-
      detects codewords from
      the time-slice symbols:
      * the time symbols
      * the position symbols
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_ALS162
    comment: |-
      Demodulation from 162 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    comment: |-
      Windows needs
      the import of
      zmq
    imports: import zmq
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      This block perfoms a
      (non-ideal) differentiation
      of the phase signal
    interp: '1'
    taps: 55*[1]+55*[-1]
    type: fff
  states: {}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: |-
      This block takes the ALS162
      signal from a simulated
      channel at 162 kHz.
    port: '55554'
    server: 'False'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      supportive lines for
      adjusting the
      threshold levels
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Phase drift
      compensation block
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      This detector runs on
      5 separate inputs, one
      for each detected level,
      instead of one input
      with all levels combined.
  states: {}
- name: note_2_0
  id: note
  parameters:
    comment: |-
      This Alternative detector
      runs on 1 composite input
      signal with all 5 levels
      additively combined.
  states: {}
- name: note_2_0_0
  id: note
  parameters:
    comment: |-
      These tresholders detect
      the four discrete signal
      levels from the noisy
      input signal
  states: {}
- name: note_2_1
  id: note
  parameters:
    comment: |-
      PLL Carrier Tracking is
      an alternative approach
      to the phase drift
      compensation
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      TDF ALS 162 signal
    dc_offset_mode0: '2'
    freq0: freq_ALS162
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: phase_shift_fct
  id: epy_module
  parameters:
    comment: |-
      phase rotates from pi
      to -pi for given poll
      frequency and given
      weight to counter-
      effect the phase drift
    source_code: |
      # this module will be imported in the into your flowgraph

      import math


      p1 = -math.pi
      p2 = +math.pi

      p = 0


      def shift_phase(weighted_trigger):
          global p1, p2, p

          if weighted_trigger:
              p = p - weighted_trigger

          if p <= p1:
              p = p2

          return p
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      weighted poll signal
      for phase shift
      correction
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '12000'
    fc: freq_ALS162
    fftsize: '1024'
    name: original spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '12000'
    fc: freq_ALS162
    fftsize: '1024'
    name: original spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: cur. phase
    label2: avg. phase
    name: Phase Drift Compensation
    nconnections: '2'
    size: int(3*samp_rate/8)
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: math.pi+0.25
    ymin: '-math.pi-0.25'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color7: dark red
    color8: dark green
    color9: dark blue
    grid: 'True'
    gui_hint: (4,0)
    label1: Phase
    label2: Derivative
    label3: '+2'
    label4: '+1'
    label5: '0'
    label6: '-1'
    label7: '-2'
    label8: Symbols
    label9: avg. Phase
    name: '"Phase Signal Decoder"'
    nconnections: '9'
    size: int(samp_rate*1/(decimation))
    srate: samp_rate
    type: float
    update_time: '0.5'
    ymax: zoom
    ymin: '-zoom'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0)
    label1: recv. sig (Re)
    label2: recv-.sig (Im)
    name: '"received complex signal"'
    size: samp_rate
    srate: samp_rate
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_0_0_2
  id: qtgui_time_sink_x
  parameters:
    color7: dark red
    color8: dark green
    color9: dark blue
    entags: 'False'
    grid: 'True'
    gui_hint: (4,1)
    label1: two_hi
    label10: one_lower_lo
    label2: two_lo
    label3: one_upper_hi
    label4: one_upper_lo
    label5: one_lower_hi
    label6: one_lower_lo
    label7: zero_hi
    label8: zero_lo
    label9: spike_thres
    name: '"Phase Signal Decoder"'
    nconnections: '10'
    size: int(samp_rate*1/(decimation))
    srate: samp_rate
    type: float
    update_time: '0.5'
    ymax: zoom
    ymin: '-zoom'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"received Signal Power"'
    size: samp_rate
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: '5'
    ymin: '-0.5'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      to thresholders of the
      differentiated signal
    stream_id: '1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '2'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '3'
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '4'
  states: {}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '5'
  states: {}
- name: virtual_sink_1_2_0
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '6'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    comment: |-
      to compute phase
      compensation
    stream_id: '7'
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    comment: |-
      to the (hidden) plot
      for threshold levels
    stream_id: '10'
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    comment: to plot
    stream_id: '8'
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      from derivative
      phase signal
    stream_id: '1'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: +1 values
    stream_id: '2'
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    comment: '-1 values'
    stream_id: '3'
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    comment: '-1 values'
    stream_id: '3'
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    comment: 0 values
    stream_id: '4'
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    comment: 0 values
    stream_id: '4'
  states: {state: disabled}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    comment: +2 values
    stream_id: '5'
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    comment: '-2 values'
    stream_id: '6'
  states: {}
- name: virtual_source_1_2_0_0
  id: virtual_source
  parameters:
    comment: '-2 values'
    stream_id: '6'
  states: {state: disabled}
- name: virtual_source_1_2_1
  id: virtual_source
  parameters:
    comment: +2 values
    stream_id: '5'
  states: {state: disabled}
- name: virtual_source_1_3
  id: virtual_source
  parameters:
    comment: +1 values
    stream_id: '2'
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: from phase
    stream_id: '7'
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    comment: |-
      average phase from the
      phase compensation block
    stream_id: '8'
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: '10'
  states: {state: disabled}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ server
      to futher decode the bits
      to human-readible
      date & time information
    timeout: '900'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_phase_shift_0, '0']
- [analog_const_source_x_0, '0', blocks_multiply_const_vxx_4, '0']
- [analog_const_source_x_0_0, '0', blocks_multiply_const_vxx_4_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_multiply_const_vxx_4_0_0, '0']
- [analog_const_source_x_0_0_0_0, '0', blocks_multiply_const_vxx_4_0_0_0, '0']
- [analog_const_source_x_0_0_0_1, '0', blocks_multiply_const_vxx_4_0_0_1, '0']
- [analog_const_source_x_0_1, '0', blocks_multiply_const_vxx_4_1, '0']
- [analog_const_source_x_0_1_0, '0', blocks_multiply_const_vxx_4_1_0, '0']
- [analog_const_source_x_0_1_0_0, '0', blocks_multiply_const_vxx_4_1_0_0, '0']
- [analog_const_source_x_0_1_1, '0', blocks_multiply_const_vxx_4_1_1, '0']
- [analog_pll_carriertracking_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', virtual_sink_3, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_char_to_float_0, '0']
- [blocks_add_const_vxx_2, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_add_const_vxx_2, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_const_vxx_2, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_add_const_vxx_2, '0', rational_resampler_xxx_1, '0']
- [blocks_add_const_vxx_4, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', epy_block_0_0, '0']
- [blocks_and_xx_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_and_xx_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_and_xx_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_and_xx_0_1, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_and_xx_0_1_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1, '0']
- [blocks_char_to_float_0, '0', virtual_sink_1_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0, '0']
- [blocks_char_to_float_0_0, '0', virtual_sink_1_2, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', virtual_sink_1_2_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', virtual_sink_1, '0']
- [blocks_char_to_float_0_0_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_char_0, '0', blocks_and_xx_0_1_0, '0']
- [blocks_float_to_char_0, '0', blocks_not_xx_0_1_2_0, '0']
- [blocks_float_to_char_0_0, '0', blocks_and_xx_0_1, '1']
- [blocks_float_to_char_0_0, '0', blocks_not_xx_0_1_2, '0']
- [blocks_float_to_char_0_0_0_0, '0', blocks_not_xx_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_and_xx_0_0, '1']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_not_xx_0_1_1, '0']
- [blocks_float_to_char_0_0_0_0_0_1, '0', blocks_and_xx_0_0_0, '1']
- [blocks_float_to_char_0_0_0_0_0_1, '0', blocks_not_xx_0_1_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_not_xx_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_moving_average_xx_0, '0', virtual_sink_4, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', virtual_sink_2, '0']
- [blocks_moving_average_xx_0_0_1, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '7']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0_0_0_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1, '0', qtgui_time_sink_x_0_0, '4']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0, '0', qtgui_time_sink_x_0_0, '6']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0_0, '0', qtgui_time_sink_x_0_0, '5']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0_0_0_1_0, '0']
- [blocks_multiply_const_vxx_3, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_4, '0', qtgui_time_sink_x_0_0_2, '6']
- [blocks_multiply_const_vxx_4_0, '0', qtgui_time_sink_x_0_0_2, '7']
- [blocks_multiply_const_vxx_4_0_0, '0', qtgui_time_sink_x_0_0_2, '5']
- [blocks_multiply_const_vxx_4_0_0_0, '0', qtgui_time_sink_x_0_0_2, '3']
- [blocks_multiply_const_vxx_4_0_0_1, '0', qtgui_time_sink_x_0_0_2, '1']
- [blocks_multiply_const_vxx_4_1, '0', qtgui_time_sink_x_0_0_2, '4']
- [blocks_multiply_const_vxx_4_1_0, '0', qtgui_time_sink_x_0_0_2, '2']
- [blocks_multiply_const_vxx_4_1_0_0, '0', qtgui_time_sink_x_0_0_2, '8']
- [blocks_multiply_const_vxx_4_1_1, '0', qtgui_time_sink_x_0_0_2, '0']
- [blocks_multiply_const_vxx_5, '0', blocks_add_const_vxx_2, '0']
- [blocks_multiply_const_vxx_6, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_6_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_6_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_6_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_6_0_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_xx_0, '0', probe_signal, '0']
- [blocks_not_xx_0, '0', blocks_and_xx_0_0, '0']
- [blocks_not_xx_0, '0', blocks_and_xx_0_0_0, '0']
- [blocks_not_xx_0_0, '0', blocks_and_xx_0_0, '2']
- [blocks_not_xx_0_0, '0', blocks_and_xx_0_0_0, '2']
- [blocks_not_xx_0_1_0, '0', blocks_and_xx_0_1_0, '1']
- [blocks_not_xx_0_1_1, '0', blocks_and_xx_0_1, '0']
- [blocks_not_xx_0_1_2, '0', blocks_and_xx_0, '0']
- [blocks_not_xx_0_1_2_0, '0', blocks_and_xx_0, '1']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_phase_shift_0, '0', virtual_sink_5, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0_0_0_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0_0_1, '0']
- [blocks_threshold_ff_0_0_0_0, '0', blocks_float_to_char_0_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_0, '0', blocks_float_to_char_0_0_0_0_0_1, '0']
- [blocks_threshold_ff_0_0_0_0_1, '0', blocks_float_to_char_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_1_0, '0', blocks_float_to_char_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_var_to_msg_0_0, msgout, blocks_phase_shift_0, shift]
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, msg_out, blocks_message_debug_0_0, print]
- [epy_block_0, msg_out, epy_block_2, msg_in]
- [epy_block_0_0, '0', blocks_add_const_vxx_4, '0']
- [epy_block_0_0, msg_out, blocks_message_debug_0_0, print]
- [epy_block_0_0, msg_out, epy_block_2, msg_in]
- [epy_block_2, msg_out, blocks_message_debug_0_0_0, print]
- [epy_block_2, msg_out, zeromq_push_msg_sink_1, in]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_const_vxx_2, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_5, '0']
- [interp_fir_filter_xxx_0, '0', blocks_moving_average_xx_0_0_1, '0']
- [network_tcp_source_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [network_tcp_source_1, '0', qtgui_freq_sink_x_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [rational_resampler_xxx_1, '0', analog_agc2_xx_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [virtual_source_1, '0', epy_block_0, '0']
- [virtual_source_1_0, '0', epy_block_0, '1']
- [virtual_source_1_0_0, '0', blocks_multiply_const_vxx_6_0_0, '0']
- [virtual_source_1_1, '0', epy_block_0, '2']
- [virtual_source_1_1_0, '0', blocks_multiply_const_vxx_6_0_0_0, '0']
- [virtual_source_1_2, '0', epy_block_0, '3']
- [virtual_source_1_2_0, '0', epy_block_0, '4']
- [virtual_source_1_2_0_0, '0', blocks_multiply_const_vxx_6_0, '0']
- [virtual_source_1_2_1, '0', blocks_multiply_const_vxx_6, '0']
- [virtual_source_1_3, '0', blocks_multiply_const_vxx_6_0_0_1, '0']
- [virtual_source_2, '0', blocks_moving_average_xx_0, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0_0, '8']
- [virtual_source_4, '0', qtgui_time_sink_x_0_0_2, '9']
- [virtual_source_5, '0', blocks_complex_to_arg_0_0, '0']

metadata:
  file_format: 1
