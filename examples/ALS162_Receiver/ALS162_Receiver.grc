options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: ALS162_Receiver
    output_language: python
    title: ALS162_Receiver
  states: {}

blocks:
- name: bits
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: diff_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: diff_gain
    start: '1'
    step: '1'
    stop: '300'
    value: '70'
  states: {}
- name: freq_ALS162
  id: variable
  parameters:
    value: '162000'
  states: {}
- name: fun_prob
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: shift_poll_freq
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Amplify receving
      signal power
    gui_hint: (0,0)
    label: Receiver Gain
    start: '1'
    step: '1'
    stop: '1000'
    value: '750'
  states: {}
- name: one_lower_hi
  id: variable_qtgui_range
  parameters:
    gui_hint: (8,0)
    label: one_lower_hi
    start: '0'
    step: '1'
    stop: '10000'
    value: '1150'
  states: {}
- name: one_lower_lo
  id: variable_qtgui_range
  parameters:
    gui_hint: (7,0)
    label: one_lower_lo
    start: '0'
    step: '1'
    stop: '10000'
    value: '1100'
  states: {}
- name: one_upper_hi
  id: variable_qtgui_range
  parameters:
    gui_hint: (10,0)
    label: one_upper_hi
    start: '0'
    step: '1'
    stop: '10000'
    value: '5150'
  states: {}
- name: one_upper_lo
  id: variable_qtgui_range
  parameters:
    gui_hint: (9,0)
    label: one_upper_lo
    start: '0'
    step: '1'
    stop: '10000'
    value: '4885'
  states: {}
- name: phase_shift
  id: variable
  parameters:
    value: phase_shift_fct.shift_freq(fun_prob)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: shift_poll_freq
  id: variable_qtgui_range
  parameters:
    label: shift_poll_freq
    start: '0'
    step: '100'
    stop: samp_rate
    value: '4000'
  states: {}
- name: shift_step
  id: variable_qtgui_range
  parameters:
    label: shift_step
    start: '0.00000'
    step: '0.00001'
    stop: '0.00150'
    value: '0.00075'
  states: {}
- name: threshold_spike
  id: variable_qtgui_range
  parameters:
    gui_hint: (13,0)
    start: '0'
    step: '100'
    stop: '25000'
    value: '15000'
  states: {}
- name: two_hi
  id: variable_qtgui_range
  parameters:
    gui_hint: (12,0)
    label: two_hi
    start: '0'
    step: '1'
    stop: '10000'
    value: '6000'
  states: {}
- name: two_lo
  id: variable_qtgui_range
  parameters:
    gui_hint: (11,0)
    label: two_lo
    start: '0'
    step: '1'
    stop: '10000'
    value: '4800'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1000'
    gain: '750'
    samp_rate: samp_rate
    width: '250'
    win: window.WIN_BLACKMAN
  states: {}
- name: zero_hi
  id: variable_qtgui_range
  parameters:
    gui_hint: (6,0)
    label: zero_hi
    start: '0'
    step: '1'
    stop: '10000'
    value: '1750'
  states: {}
- name: zero_lo
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,0)
    label: zero_lo
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: zoom
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0)
    label: zoom
    start: '0'
    step: '10'
    stop: '25000'
    value: '8000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: gain
    reference: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: zero_hi
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: zero_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: one_lower_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: one_upper_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0_0_1
  id: analog_const_source_x
  parameters:
    const: two_lo
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: one_lower_hi
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: one_upper_hi
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1_0_0
  id: analog_const_source_x
  parameters:
    const: threshold_spike
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1_1
  id: analog_const_source_x
  parameters:
    const: two_hi
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_1
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      no function
      intended!
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      needed, but unclear
      why logical AND-gate
      provides something
      different than 0 or 1
    const: '2'
    type: byte
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    comment: get 0 value
    type: byte
  states: {}
- name: blocks_and_xx_0_0
  id: blocks_and_xx
  parameters:
    comment: get +2 value
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_and_xx_0_0_0
  id: blocks_and_xx
  parameters:
    comment: get -2 value
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_and_xx_0_1
  id: blocks_and_xx
  parameters:
    comment: get +1 value
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0
  id: blocks_and_xx
  parameters:
    comment: get -1 value
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      to obtain the
      phase of the
      complex signal
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0_1_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: compute average phase
    length: '500000'
    max_iter: '4000'
    scale: 1/500000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      to remove glitches
      from a noisy
      derivation of the phase
    length: '500'
    max_iter: '4000'
    scale: 1/500
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      to remove glitches
      from a noisy phase
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      just to be visible in the
      (non-normalized) plot
    const: '1000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: positive values
    const: '+1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: positive values
    const: diff_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: bits
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bits+300
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-bits-300'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bits+200
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-bits-200'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: negative values
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      just to be visible
      in the (non-normalized)
      plot
    const: '1000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/750
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: |-
      weighting parameter for
      corrective feedback
    const: shift_step
    type: float
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_1
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_2
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_1_2_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    comment: |-
      apply phase drift
      correction by shifting
      the phase to the
      opposite direction
      towards zero
    is_radians: 'True'
    shift: '0'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: extreme spike upwards
    high: threshold_spike
    init: '0'
    low: threshold_spike
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    comment: extreme spike downwards
    high: threshold_spike
    init: '0'
    low: threshold_spike
  states: {}
- name: blocks_threshold_ff_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      above this value
      is a +2
    high: two_hi
    init: '0'
    low: two_lo
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      above this value
      is a -2
    high: two_hi
    init: '0'
    low: two_lo
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      above this value
      is a +1
    high: one_lower_hi
    init: '0'
    low: one_lower_lo
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      below this value
      is a +1
    high: one_upper_lo
    init: '0'
    low: one_upper_hi
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      below this value
      is a -1
    high: one_upper_lo
    init: '0'
    low: one_upper_hi
  states: {}
- name: blocks_threshold_ff_0_0_0_0_0_0_1
  id: blocks_threshold_ff
  parameters:
    comment: |-
      above this value
      is a -1
    high: one_lower_hi
    init: '0'
    low: one_lower_lo
  states: {}
- name: blocks_threshold_ff_0_0_0_0_1
  id: blocks_threshold_ff
  parameters:
    comment: |-
      below this value
      is a 0
    high: zero_hi
    init: '0'
    low: zero_lo
  states: {}
- name: blocks_threshold_ff_0_0_0_0_1_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      below this value
      is a 0
    high: zero_hi
    init: '0'
    low: zero_lo
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    comment: |-
      get phase drift correction
      value from probe function
    msgname: ampl
    target: phase_shift
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      # the detector is initially out of sync
      _in_sync = 0

      # counted number of one samples for +1
      _num_ones_p1 = 0
      # counted number of one samples for -1
      _num_ones_m1 = 0
      # counted number of one samples for  0
      _num_ones_z0 = 0
      # counted number of one samples for +2
      _num_ones_p2 = 0
      # counted number of one samples for -2
      _num_ones_m2 = 0

      # counts number of samples after a zero- or
      # one-symbol has been detected
      _skip_count = 0
      # determines how many samples shall be skipped
      # after the detection of a zero- or one-symbol
      _cur_skipframe = 50000
      _cur_sec = 0


      class blk(gr.sync_block):

          def __init__(self, scaling=8, sample_rate=192000,
                       tolerance=0.002, debug=False):
              gr.sync_block.__init__(
                  self,
                  name='Bit-Detector ALS162',
                  in_sig=[np.float32, np.float32, np.float32,
                          np.float32, np.float32],
                  out_sig=[np.float32]
              )

              self.scaling = scaling
              self.sample_rate = sample_rate
              self._tolerance = self.sample_rate/self.scaling*tolerance

              # True: display status-tags
              self.debug = debug

              # messaging port
              self.message_port_register_out(pmt.intern('msg_out'))

              """
              values from slope signal computed by derivative FIR filter
              symbols are constructed by a sequence of clocked sub-frames
              Zero-Symbol:
              0, +1, -1, -1, +1, 0, 0, 0, 0

              One-Symbol:
              0, +1, -1, -1, +1, +1, -1, -1, +1

              New-Minute-Symbol:
              1275 ms a sequence 0 values only
              """

              # each subframe lasts approx. 25ms
              self._subframe_lo = int(0.025 * self.sample_rate/self.scaling
                                      - self._tolerance)
              self._subframe_hi = int(0.025 * self.sample_rate/self.scaling
                                      + self._tolerance)

              # lasts roughly 1275 ms
              self._reinit_zero_lo = int(1.275*self.sample_rate/self.scaling
                                         - 4*self._tolerance)
              self._reinit_zero_hi = int(1.275*self.sample_rate/self.scaling
                                         + 4*self._tolerance)

              # after a successful zero or one-symbol has been detected
              # ignore the signal for almost the rest of the second
              self._skipframe_zero = int(0.8*self.sample_rate/self.scaling
                                         - self._tolerance)
              self._skipframe_one = int(0.7*self.sample_rate/self.scaling
                                        - self._tolerance)

              print("zero_reinit_length", (self._reinit_zero_hi
                                           + self._reinit_zero_lo)/2)
              print("subframe_length: ", (self._subframe_hi + self._subframe_lo)/2)
              print("skipframe_zero_length: ", self._skipframe_zero)
              print("skipframe_one_length: ", self._skipframe_one)
              print("tolerance_length: ", self._tolerance)

          def work(self, input_items, output_items):
              inp_p1 = input_items[0]     # +1
              inp_m1 = input_items[1]     # -1
              inp_z0 = input_items[2]     # 0
              inp_p2 = input_items[3]     # +2
              inp_m2 = input_items[4]     # -2

              out = output_items[0]

              out[:] = self.extract_bits(inp_p1, inp_m1, inp_z0, inp_p2, inp_m2)

              # forward input tagged signal
              return len(output_items[0])

          def clear_counters(self):
              global _num_ones_p1
              global _num_ones_m1
              global _num_ones_z0
              global _num_ones_p2
              global _num_ones_m2

              _num_ones_p1 = 0
              _num_ones_m1 = 0
              _num_ones_z0 = 0
              _num_ones_p2 = 0
              _num_ones_m2 = 0

              # _cur_sec = 0

          def extract_bits(self, inp_p1, inp_m1, inp_z0, inp_p2, inp_m2):
              global _in_sync
              global _skip_count
              global _cur_skipframe
              global _cur_sec

              global _num_ones_p1
              global _num_ones_m1
              global _num_ones_z0
              global _num_ones_p2
              global _num_ones_m2

              # -1 => represents no relevant output
              out = -np.ones(len(inp_p1))

              # iterate through all three (parallel) input streams concurrently
              for idx in range(len(inp_p1)):
                  # get symbol values at same idx for each input stream
                  ch_p1 = inp_p1[idx]
                  ch_m1 = inp_m1[idx]
                  ch_z0 = inp_z0[idx]
                  ch_p2 = inp_p2[idx]
                  ch_m2 = inp_m2[idx]

                  if ch_z0 == 1:
                      _num_ones_z0 += 1

                  if _cur_sec > 59:
                      _cur_sec = 0

                  # to avoid an overflow of _skip_count
                  # stop counting after given limit and hold the value
                  if _skip_count < _cur_skipframe + 1:
                      # after a zero or one has been detected
                      # the next bit should not be detected earlier
                      # than the duration of the skip frame
                      # (slightly less than a second)
                      _skip_count += 1

                  else:
                      _skip_count = _cur_skipframe + 15

                      # increment current counters of ones per
                      # input stream, correspondingly
                      if ch_p1 == 1:
                          _num_ones_p1 += 1

                      if ch_m1 == 1:
                          _num_ones_m1 += 1

                      # any p2-symbol will trigger a de-sync
                      if ch_p2 == 1:
                          _num_ones_p2 += 1
                          _in_sync = 0

                      # any m2-symbol will trigger a de-sync
                      if ch_m2 == 1:
                          _num_ones_m2 += 1
                          _in_sync = 0

                      # 1st step of synchronization
                      if _in_sync == 0:
                          if (_num_ones_z0 >= self._reinit_zero_lo and
                                  _num_ones_z0 <= self._reinit_zero_hi):

                              self.clear_counters()

                              # marking detected new minute
                              key = pmt.intern("b")
                              value = pmt.intern("new minute")
                              self.add_item_tag(0,
                                                self.nitems_written(0) + idx,
                                                key,
                                                value)

                              # new minute-symbol for ALS162-decoder
                              self.message_port_pub(pmt.intern("msg_out"),
                                                    pmt.intern("2"))

                              out[idx] = 3

                              _cur_sec = 0

                          if (ch_p1 == 1 and
                                  _num_ones_z0 >= self._subframe_lo):
                              _in_sync = 1

                              self.clear_counters()
                              _num_ones_p1 = 1

                              if self.debug is True:
                                  key = pmt.intern("s")
                                  value = pmt.intern("1")
                                  self.add_item_tag(0,
                                                    self.nitems_written(0) + idx,
                                                    key,
                                                    value)

                          # do not (yet) synchronize
                          elif ch_p1 == 0:
                              _num_ones_p1 = 0
                              _num_ones_m1 = 0
                              # _num_ones_z0 = 0
                              _num_ones_p2 = 0
                              _num_ones_m2 = 0

                      elif _in_sync == 1:
                          # detect end of subframe 2
                          if (ch_p1 == 0 and
                                  (_num_ones_p1 >= self._subframe_lo and
                                   _num_ones_p1 <= self._subframe_hi)):
                              _in_sync = 2

                              self.clear_counters()

                              if self.debug is True:
                                  key = pmt.intern("s")
                                  value = pmt.intern("2")
                                  self.add_item_tag(0,
                                                    self.nitems_written(0) + idx,
                                                    key,
                                                    value)

                          # out of sync
                          elif (ch_p1 == 0 and
                                  (_num_ones_p1 < self._subframe_lo or
                                   _num_ones_p1 > self._subframe_hi)):
                              _in_sync = 0

                              self.clear_counters()

                      elif _in_sync == 2:
                          # detect end of subframe 3
                          if (_num_ones_m1 >= 2*self._subframe_lo and
                                  _num_ones_m1 <= 2*self._subframe_hi):
                              _in_sync = 3

                              self.clear_counters()

                              if self.debug is True:
                                  key = pmt.intern("s")
                                  value = pmt.intern("3")
                                  self.add_item_tag(0,
                                                    self.nitems_written(0) + idx,
                                                    key,
                                                    value)

                          # out of sync
                          elif _num_ones_m1 > 2*self._subframe_hi:
                              _in_sync = 0

                              self.clear_counters()

                          elif _num_ones_z0 >= 2*self._tolerance:
                              _in_sync = 0

                              self.clear_counters()

                      elif _in_sync == 3:
                          # detect end of subframe 5
                          if (_num_ones_p1 > self._subframe_lo and
                                  _num_ones_p1 < self._subframe_hi and ch_p1 == 0):
                              _in_sync = 5

                              self.clear_counters()

                              if self.debug is True:
                                  key = pmt.intern("s")
                                  value = pmt.intern("5")
                                  self.add_item_tag(0,
                                                    self.nitems_written(0) + idx,
                                                    key,
                                                    value)

                          # detect end of subframe 6
                          if (_num_ones_p1 >= 2*self._subframe_lo and
                                  _num_ones_p1 <= 2*self._subframe_hi):
                              _in_sync = 6

                              self.clear_counters()

                              if self.debug is True:
                                  key = pmt.intern("s")
                                  value = pmt.intern("6")
                                  self.add_item_tag(0,
                                                    self.nitems_written(0) + idx,
                                                    key,
                                                    value)

                          # out of sync
                          elif _num_ones_p1 > 2*self._subframe_hi:
                              _in_sync = 0

                              self.clear_counters()

                          elif _num_ones_z0 > 2*self._tolerance:
                              _in_sync = 0

                              self.clear_counters()

                      elif _in_sync == 5:
                          # detect subframe 6
                          if (_num_ones_z0 >= 1*self._subframe_lo and
                                  _skip_count >= _cur_skipframe):
                              _in_sync = 0

                              self.clear_counters()

                              # marking detected zero-symbol
                              key = pmt.intern("b")
                              value = pmt.intern("0")
                              self.add_item_tag(0,
                                                self.nitems_written(0) + idx,
                                                key,
                                                value)

                              # successfully detected a zero symbol
                              # print("Sec: ", _cur_sec)
                              self.message_port_pub(pmt.intern("msg_out"),
                                                    pmt.intern("0"))
                              out[idx] = 1

                              _cur_sec += 1

                              # reset skip counter
                              _skip_count = 0
                              _cur_skipframe = self._skipframe_zero

                          elif _num_ones_p1 >= 2*self._tolerance:
                              _in_sync = 0

                              self.clear_counters()

                      elif _in_sync == 6:
                          # detect end of subframe 7
                          if (_num_ones_m1 >= 2*self._subframe_lo and
                                  _num_ones_m1 <= 2*self._subframe_hi):
                              _in_sync = 7

                              self.clear_counters()

                              if self.debug is True:
                                  key = pmt.intern("s")
                                  value = pmt.intern("7")
                                  self.add_item_tag(0,
                                                    self.nitems_written(0) + idx,
                                                    key,
                                                    value)

                          # out of sync
                          elif (_num_ones_z0 > self._subframe_hi):
                              _in_sync = 0

                              self.clear_counters()

                      elif _in_sync == 7:
                          if (_num_ones_p1 >= self._subframe_lo and
                                  _num_ones_p1 <= self._subframe_hi and
                                  _skip_count >= _cur_skipframe):
                              _in_sync = 0

                              self.clear_counters()

                              # marking detected zero-symbol
                              key = pmt.intern("b")
                              value = pmt.intern("1")
                              self.add_item_tag(0,
                                                self.nitems_written(0) + idx,
                                                key,
                                                value)

                              # successfully detected a one symbol
                              # print("Sec: ", _cur_sec)
                              self.message_port_pub(pmt.intern("msg_out"),
                                                    pmt.intern("1"))
                              out[idx] = 2

                              _cur_sec += 1

                              # reset skip counter
                              _skip_count = 0
                              _cur_skipframe = self._skipframe_one

                          elif _num_ones_z0 >= 2*self._tolerance:
                              _in_sync = 0

                              self.clear_counters()

              return out
    comment: |-
      detects:
      * Zero-Symbol
      * One-Symbol
      * Minute-Symbol
    debug: 'False'
    sample_rate: '192000'
    scaling: '8'
    tolerance: '0.003'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_ALS162
    comment: |-
      Demodulation from 162 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    alias: Differentiator
    comment: |-
      An averaging FIR differentiator
      to obtain the derivative of the
      phase signal
    fbtaps: (0)
    fftaps: |-
      (+4,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,+1,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      +0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,+0,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,
      -1,-1,-4)
    oldstyle: 'False'
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    comment: |-
      Windows needs
      the import of
      zmq
    imports: import zmq
  states: {}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: |-
      This block takes the ALS162
      signal from a simulated
      channel at 162 kHz.
    port: '55554'
    server: 'False'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      supportive lines for
      adjusting the
      threshold levels
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    comment: Phase drift compensation block
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      TDF ALS 162 signal
    dc_offset_mode0: '2'
    freq0: freq_ALS162
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: phase_shift_fct
  id: epy_module
  parameters:
    comment: |-
      phase rotates from pi to -pi
      for given poll frequency and 
      given weight to countereffect
      the phase drift
    source_code: |
      # this module will be imported in the into your flowgraph


      import math


      f1 = -math.pi
      f2 = +math.pi

      f = 0


      def shift_freq(weighted_trigger):
          global f1, f2, f

          if weighted_trigger:
              f = f - weighted_trigger

          if f <= f1:
              f = f2

          return f
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      weighted poll signal
      for phase shift correction
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '12000'
    fc: freq_ALS162
    fftsize: '1024'
    name: original spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: cur. phase
    label2: avg. phase
    name: Phase Drift Compensation
    nconnections: '2'
    size: 3*samp_rate
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: math.pi+0.25
    ymin: '-math.pi-0.25'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color7: dark red
    color8: dark green
    color9: dark blue
    grid: 'True'
    gui_hint: (4,0)
    label1: Phase
    label2: Derivative
    label3: '+2'
    label4: '+1'
    label5: '0'
    label6: '-1'
    label7: '-2'
    label8: Symbols
    label9: avg. Phase
    name: '"Phase Signal Decoder"'
    nconnections: '9'
    size: int(samp_rate*1/(decimation))
    srate: samp_rate
    type: float
    update_time: '0.5'
    ymax: zoom
    ymin: '-zoom'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0)
    label1: ''
    label2: ''
    name: '"received complex signal"'
    size: samp_rate*2
    srate: samp_rate
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_time_sink_x_0_0_2
  id: qtgui_time_sink_x
  parameters:
    color7: dark red
    color8: dark green
    color9: dark blue
    entags: 'False'
    grid: 'True'
    gui_hint: (4,1)
    label1: two_hi
    label10: one_lower_lo
    label2: two_lo
    label3: one_upper_hi
    label4: one_upper_lo
    label5: one_lower_hi
    label6: one_lower_lo
    label7: zero_hi
    label8: zero_lo
    label9: spike_thres
    name: '"Phase Signal Decoder"'
    nconnections: '10'
    size: int(samp_rate*1/(decimation))
    srate: samp_rate
    type: float
    update_time: '0.5'
    ymax: zoom
    ymin: '-zoom'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      to reduce overall
      time critical
      computational
      effort of the
      decoder
    decim: decimation
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      to reduce overall computational
      complexity of the decoder
    decim: decimation
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      to reduce overall computational
      complexity of the decoder and 
      in accordance to the plot
    decim: decimation
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      to thresholders of the
      differentiated signal
    stream_id: '1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '2'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '3'
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '4'
  states: {}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '5'
  states: {}
- name: virtual_sink_1_2_0
  id: virtual_sink
  parameters:
    comment: to ALS162 bit detector
    stream_id: '6'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    comment: |-
      to compute phase
      compensation
    stream_id: '7'
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    comment: |-
      to the (hidden) plot
      for threshold levels
    stream_id: '10'
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    comment: to plot
    stream_id: '8'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      from differentiated
      phase signal
    stream_id: '1'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: +1 values
    stream_id: '2'
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    comment: '-1 values'
    stream_id: '3'
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    comment: 0 values
    stream_id: '4'
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    comment: +2 values
    stream_id: '5'
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    comment: '-2 values'
    stream_id: '6'
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: from phase
    stream_id: '7'
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    comment: |-
      average phase from the
      phase compensation block
    stream_id: '8'
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: '10'
  states: {state: disabled}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ server
      to futher decode the bits
      to human-readible
      date & time information
    timeout: '900'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_phase_shift_0, '0']
- [analog_const_source_x_0, '0', blocks_multiply_const_vxx_4, '0']
- [analog_const_source_x_0_0, '0', blocks_multiply_const_vxx_4_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_multiply_const_vxx_4_0_0, '0']
- [analog_const_source_x_0_0_0_0, '0', blocks_multiply_const_vxx_4_0_0_0, '0']
- [analog_const_source_x_0_0_0_1, '0', blocks_multiply_const_vxx_4_0_0_1, '0']
- [analog_const_source_x_0_1, '0', blocks_multiply_const_vxx_4_1, '0']
- [analog_const_source_x_0_1_0, '0', blocks_multiply_const_vxx_4_1_0, '0']
- [analog_const_source_x_0_1_0_0, '0', blocks_multiply_const_vxx_4_1_0_0, '0']
- [analog_const_source_x_0_1_1, '0', blocks_multiply_const_vxx_4_1_1, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '7']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', virtual_sink_3, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0_1, '0', iir_filter_xxx_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_char_to_float_0, '0']
- [blocks_and_xx_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_and_xx_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_and_xx_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_and_xx_0_1, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_and_xx_0_1_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1, '0']
- [blocks_char_to_float_0, '0', virtual_sink_1_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0, '0']
- [blocks_char_to_float_0_0, '0', virtual_sink_1_2, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', virtual_sink_1_2_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', virtual_sink_1, '0']
- [blocks_char_to_float_0_0_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_not_xx_0_1_2_0, '0']
- [blocks_float_to_char_0_0, '0', blocks_not_xx_0_1_2, '0']
- [blocks_float_to_char_0_0_0, '0', blocks_and_xx_0_0, '1']
- [blocks_float_to_char_0_0_0, '0', blocks_not_xx_0_1_1, '0']
- [blocks_float_to_char_0_0_0_0, '0', blocks_not_xx_0, '0']
- [blocks_float_to_char_0_0_0_0_0, '0', blocks_not_xx_0_1, '0']
- [blocks_float_to_char_0_0_0_0_0_0, '0', blocks_and_xx_0_1, '2']
- [blocks_float_to_char_0_0_0_0_0_0_0, '0', blocks_and_xx_0_1_0, '0']
- [blocks_float_to_char_0_0_0_0_0_1, '0', blocks_not_xx_0_1_0, '0']
- [blocks_float_to_char_0_0_0_1, '0', blocks_not_xx_0_0, '0']
- [blocks_float_to_char_0_0_0_1_0, '0', blocks_and_xx_0_0_0, '1']
- [blocks_float_to_char_0_0_0_1_0, '0', blocks_not_xx_0_1_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_moving_average_xx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_add_const_vxx_0_0_0_1, '0']
- [blocks_moving_average_xx_0_0_0, '0', virtual_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_0_0_0_0_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1, '0', qtgui_time_sink_x_0_0, '4']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0, '0', qtgui_time_sink_x_0_0, '6']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_multiply_const_vxx_1_0_0_0_0_1_1_0_0_0_0, '0', qtgui_time_sink_x_0_0, '5']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0_0_0_0_0_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0_0_0_0_1_0, '0']
- [blocks_multiply_const_vxx_3, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_4, '0', qtgui_time_sink_x_0_0_2, '6']
- [blocks_multiply_const_vxx_4_0, '0', qtgui_time_sink_x_0_0_2, '7']
- [blocks_multiply_const_vxx_4_0_0, '0', qtgui_time_sink_x_0_0_2, '5']
- [blocks_multiply_const_vxx_4_0_0_0, '0', qtgui_time_sink_x_0_0_2, '3']
- [blocks_multiply_const_vxx_4_0_0_1, '0', qtgui_time_sink_x_0_0_2, '1']
- [blocks_multiply_const_vxx_4_1, '0', qtgui_time_sink_x_0_0_2, '4']
- [blocks_multiply_const_vxx_4_1_0, '0', qtgui_time_sink_x_0_0_2, '2']
- [blocks_multiply_const_vxx_4_1_0_0, '0', qtgui_time_sink_x_0_0_2, '8']
- [blocks_multiply_const_vxx_4_1_1, '0', qtgui_time_sink_x_0_0_2, '0']
- [blocks_multiply_const_vxx_5, '0', analog_agc2_xx_0, '0']
- [blocks_multiply_const_vxx_5, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_xx_0, '0', probe_signal, '0']
- [blocks_not_xx_0, '0', blocks_and_xx_0_0, '0']
- [blocks_not_xx_0, '0', blocks_and_xx_0_0_0, '0']
- [blocks_not_xx_0_0, '0', blocks_and_xx_0_0, '2']
- [blocks_not_xx_0_0, '0', blocks_and_xx_0_0_0, '2']
- [blocks_not_xx_0_1, '0', blocks_and_xx_0_1, '1']
- [blocks_not_xx_0_1_0, '0', blocks_and_xx_0_1_0, '1']
- [blocks_not_xx_0_1_0_0, '0', blocks_and_xx_0_1_0, '2']
- [blocks_not_xx_0_1_1, '0', blocks_and_xx_0_1, '0']
- [blocks_not_xx_0_1_2, '0', blocks_and_xx_0, '0']
- [blocks_not_xx_0_1_2_0, '0', blocks_and_xx_0, '1']
- [blocks_phase_shift_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0_0_0_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0_0_1, '0']
- [blocks_threshold_ff_0_0_0_0, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_0, '0', blocks_float_to_char_0_0_0_1_0, '0']
- [blocks_threshold_ff_0_0_0_0_0_0, '0', blocks_float_to_char_0_0_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_0_0_0, '0', blocks_float_to_char_0_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_0_0_0_0, '0', blocks_float_to_char_0_0_0_0_0_1, '0']
- [blocks_threshold_ff_0_0_0_0_0_0_1, '0', blocks_float_to_char_0_0_0_0_0_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_1, '0', blocks_float_to_char_0_0, '0']
- [blocks_threshold_ff_0_0_0_0_1_0, '0', blocks_float_to_char_0, '0']
- [blocks_var_to_msg_0_0, msgout, blocks_phase_shift_0, shift]
- [epy_block_1, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_1, msg_out, blocks_message_debug_0, print]
- [epy_block_1, msg_out, zeromq_push_msg_sink_1, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_5, '0']
- [iir_filter_xxx_0, '0', blocks_moving_average_xx_0_0, '0']
- [network_tcp_source_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_3, '0']
- [rational_resampler_xxx_0_0_0, '0', virtual_sink_4, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', epy_block_1, '0']
- [virtual_source_1_0, '0', epy_block_1, '1']
- [virtual_source_1_1, '0', epy_block_1, '2']
- [virtual_source_1_2, '0', epy_block_1, '3']
- [virtual_source_1_2_0, '0', epy_block_1, '4']
- [virtual_source_2, '0', blocks_moving_average_xx_0, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0_0, '8']
- [virtual_source_4, '0', qtgui_time_sink_x_0_0_2, '9']

metadata:
  file_format: 1
